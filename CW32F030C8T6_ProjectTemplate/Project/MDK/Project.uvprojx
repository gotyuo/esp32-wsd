# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: CW32F030C8 WHXY
  pack: WHXY.CW32F030_DFP.1.0.5
  cpu: IRAM(0x20000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\APP;..\..\Board;..\..\BSP;..\..\Libraries\inc;..\..\Module;..\..\BSP\uart;..\..\BSP\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ../../APP/: main.c
    ../../Libraries/src/: system_cw32f030.c
  group STARTUP
    ../../APP/: startup_cw32f030.s
  group BSP
    ../../BSP/uart/: bsp_uart.c
    ../../BSP/LCD/: lcd.c lcd_init.c
  group Board
    ../../Board/: board.c
  group Driver
    ../../Libraries/src/: cw32f030_adc.c cw32f030_atim.c cw32f030_awt.c cw32f030_btim.c cw32f030_crc.c cw32f030_debug.c cw32f030_digitalsign.c cw32f030_dma.c cw32f030_flash.c cw32f030_gpio.c cw32f030_gtim.c cw32f030_iwdt.c cw32f030_lvd.c cw32f030_pwr.c cw32f030_ram.c cw32f030_rcc.c cw32f030_rtc.c cw32f030_spi.c cw32f030_systick.c cw32f030_uart.c cw32f030_vc.c cw32f030_wwdt.c
  group DOC
    ../../: README.md
software components: CMSIS:CORE 5.6.0
